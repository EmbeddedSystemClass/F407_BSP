# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, STM32F407xx, RT_USING_ARM_LIBC
  c include: .;rt-thread\include;applications;.;applications\app;applications\driver;packages\LedBlink-v1.0.0;.;board;board\CubeMX_Config\Inc;libraries\HAL_Drivers;libraries\HAL_Drivers\config;packages\libmodbus-latest\examples;packages\libmodbus-latest\inc;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;rt-thread\components\net\sal_socket\include;rt-thread\components\net\sal_socket\include\socket;rt-thread\components\net\sal_socket\include\dfs_net;rt-thread\components\net\sal_socket\include\dfs_net\sys_select;rt-thread\components\net\sal_socket\include\socket\sys_socket;rt-thread\components\utilities\ulog;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;libraries\STM32F4xx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
    applications/app/: app_ae.c app_tev.c modbus_slave.c
    packages/LedBlink-v1.0.0/: ledblink.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c usart.c dma.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_spi.c drv_common.c
  group libmodbus
    packages/libmodbus-latest/src/: modbus.c modbus-data.c modbus-rtu.c modbus-tcp.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    rt-thread/components/libc/compilers/common/: gmtime_r.c
  group SAL
    rt-thread/components/net/sal_socket/src/: sal_ipaddr.c sal_socket.c
    rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
  group STM32_HAL
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_hal_qspi.c
software components: CMSIS:CORE 5.2.0
